# Repository TheBadZhang/LED-LIGHT-USB

File readme.md:

# 陶瓷灯丝 LED

很简单的电路设计，没有什么特别值得说的

简而言之就是USB供电，通过一个限流保护开关，然后通过一个LED驱动芯片驱动4串LED，通过一个LED触摸控制芯片控制灯的亮度

焊接的时候需要注意LED的正负，我买的陶瓷灯丝LED上是有孔的一端为正，对应圆角矩形的一端为正，椭圆矩形的一端为负

## KiCad design main.kicad_pcb

Parts:
C1, C4: 10uF; C_0603_1608Metric
C2: 100nF; C_0603_1608Metric
C3: 10nF; C_0603_1608Metric
C5: 4.7uF; C_0603_1608Metric
D1, D2, D3, D4: LED; 陶瓷灯丝LED-26mm
D5: DSS14; D_SOD-123F
J2: USB_A; USB_A_CNCTech_1001-011-01101_Horizontal
L1: 10uH; L_Abracon_ASPI-3012S
R1, R3, R4: 10K; R_0603_1608Metric
R2: 1K; R_0603_1608Metric
R5: 2R; R_0603_1608Metric
R6: 510R; R_0603_1608Metric
SYMBOL1: 符号; 手指符号
SYMBOL2: 符号; OSHW-Logo2_14.6x12mm_SilkScreen
TP1: TestPoint
U1: JL8022WJL; SOIC-8_3.9x4.9mm_P1.27mm
U2: SY7200; SOT-23-6
U3: SY6280; SOT-23-5

Connections:
+5V: C1.1, C2.1, L1.1, R1.1, U1.3 (VDD), U2.6 (IN), U3.1 (OUT)
/LX: D5.2 (A), L1.2, U2.1 (LX)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J2.4 (GND), J2.5 (Shield), R3.1, R4.1, R5.2, U1.4 (GND), U1.8 (OP2), U2.2 (GND), U3.2 (GND)
unnamed: C5.1, D1.2 (A), D5.1 (K), U2.5 (OVP)
unnamed: D1.1 (K), D2.2 (A)
unnamed: D2.1 (K), D3.2 (A)
unnamed: D3.1 (K), D4.2 (A)
unnamed: D4.1 (K), R5.1, U2.3 (FB)
unnamed: R6.1, TP1.1
unnamed: R1.2, U1.6 (OP1)
unnamed: R2.1, U1.7 (SO)
unnamed: R6.2, U1.5 (TI)
unnamed: C3.1, U1.2 (VC)
unnamed: R2.2, R3.2, U2.4 (EN)
unnamed: R4.2, U3.3 (ISET)
VBUS: C4.1, J2.1 (VBUS), U3.4 (EN), U3.5 (IN)

Notes on the sheet:
USB
恒流控制
V_{out}_{max}=3V*4=12V
I_{lim}=100mA
过流保护
不使用恒流芯片，发热量为原先的16倍（不含LED）
V_{ref}=0.2V
使用恒流芯片发热约为0.01*各支路负载电阻
I_{lim}=6800/10K(A)
I_{lim}=0.68(A)
效率约为90%
陶瓷灯丝LED
正常工作最大电流 1.2W/0.9+0.2=1.5W 1.5W/5V=0.3A=300mA
I_{lim}=6800/R(A)
P_{max}=12V*0.1A=1.2W
LED亮度控制
OPT2 OPT1 模式名称 模式说明 1 1 无级调光 无亮度记忆无缓冲触摸无级调光功能 1 0 无级调光 无亮度记忆带缓冲触摸无级调光功能 0 1 无级调光 带亮度记忆带缓冲触摸无级调光功能 0 0 三段调光 三段触摸调光功能
通常能够提供500mA的电流

Board: 2 copper layers, 51.8 x 14.5 mm, 23 parts (2 on the bottom side), 15 nets.

## Commit log

2024-09-26 小灯验证通过
